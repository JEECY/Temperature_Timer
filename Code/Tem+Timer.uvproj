# Keil uVision project Tem+Timer.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Tem+Timer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./User/: ds1302.c LQ12864.c main.c delay.c ds18b20.c beep.c all.c key.c
